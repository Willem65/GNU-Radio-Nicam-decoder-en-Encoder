options:
  parameters:
    generate_options: qt_gui
    id: BPSKproject1
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW_tune
  id: variable_qtgui_range
  parameters:
    label: '"BW"'
    min_len: '20'
    start: '0.001'
    step: '0.01'
    stop: '5'
    value: '2'
  states: {}
- name: access_code
  id: variable
  parameters:
    value: digital.packet_utils.default_access_code
  states: {}
- name: bpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1, 1]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: buffer_size
  id: variable
  parameters:
    value: '65536'
  states: {}
- name: freq_tune
  id: variable_qtgui_range
  parameters:
    label: '"Frequentie"'
    min_len: '20'
    rangeType: int
    start: '439450000'
    step: '100'
    stop: '439850000'
    value: '439605500'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_code, 0)
  states: {}
- name: pkt_len
  id: variable
  parameters:
    comment: Aantal audiobytes per pakket (payload-grootte, vóór CRC/header)
    value: '256'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: pkt_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: packet_len
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_additive_scrambler_xx_0_0
  id: digital_additive_scrambler_xx
  parameters:
    bits_per_byte: '8'
    count: '0'
    len: '7'
    mask: '0x8A'
    reset_tag_key: packet_len
    seed: '0x7F'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk_const
    differential: 'False'
    excess_bw: BW_tune
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    tagname: packet_len
    threshold: '3'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    minoutbuf: buffer_size
    order: '2'
    w: '0.5'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_crc32_bb_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: packet_len
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.414'
    loop_bw: '0.15'
    max_dev: '1.5'
    minoutbuf: buffer_size
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.5'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nfrom collections import deque\n\nclass blk(gr.sync_block):\n    \"\"\"UDP-PDU's naar een ononderbroken bytestroom, met filler zodra\n    de buffer leeg is. Buffergrootte is nu gekoppeld aan een maximale\n    vertraging in plaats van een vast aantal bytes.\"\"\"\n\n    def __init__(self, filler_byte=0, max_latency_sec=2.0, channel_bytes_per_sec=150):\n        gr.sync_block.__init__(\n            self,\n            name='PDU naar continue stream (met filler, beperkte latency)',\n            in_sig=None,\n            out_sig=[np.uint8]\n        )\n        self.filler_byte = int(filler_byte) & 0xFF\n        # Buffergrootte = max_latency_sec * kanaalcapaciteit.\n        # Zodra dit vol is, vallen de OUDSTE bytes vanzelf weg (deque-gedrag),\n        # zodat de vertraging nooit verder oploopt dan max_latency_sec.\n        max_bytes = max(1, int(max_latency_sec * channel_bytes_per_sec))\n        self.buf = deque(maxlen=max_bytes)\n        self.message_port_register_in(pmt.intern('pdus'))\n        self.set_msg_handler(pmt.intern('pdus'), self.handle_pdu)\n\n    def handle_pdu(self, msg):\n        data = pmt.cdr(msg)\n        if pmt.is_u8vector(data):\n            self.buf.extend(pmt.u8vector_elements(data))\n\n    def work(self, input_items, output_items):\n        out = output_items[0]\n        for i in range(len(out)):\n            out[i] = self.buf.popleft() if self.buf else self.filler_byte\n        return len(out)\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n\n# import numpy as np\n# from gnuradio import gr\n# import pmt\n# from collections import deque\n\n# class blk(gr.sync_block):\n    # \"\"\"UDP-PDU's naar een ononderbroken bytestroom, met filler zodra de buffer leeg is\"\"\"\n\n    # def __init__(self, filler_byte=0):\n        # gr.sync_block.__init__(\n            # self,\n            # name='PDU naar continue stream (met filler)',\n            # in_sig=None,\n            # out_sig=[np.uint8]\n        # )\n        # self.filler_byte = int(filler_byte) & 0xFF\n        # # maxlen voorkomt dat de buffer eindeloos opzwelt als UDP sneller\n        # # binnenkomt dan er wordt uitgezonden; oudste bytes vallen dan vanzelf af\n        # self.buf = deque(maxlen=1_000_000)\n        # self.message_port_register_in(pmt.intern('pdus'))\n        # self.set_msg_handler(pmt.intern('pdus'), self.handle_pdu)\n\n    # def handle_pdu(self, msg):\n        # data = pmt.cdr(msg)\n        # if pmt.is_u8vector(data):\n            # self.buf.extend(pmt.u8vector_elements(data))\n\n    # def work(self, input_items, output_items):\n        # out = output_items[0]\n        # for i in range(len(out)):\n            # out[i] = self.buf.popleft() if self.buf else self.filler_byte\n        # return len(out)\n        \n        "
    channel_bytes_per_sec: '15000'
    filler_byte: '85'
    max_latency_sec: '2'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Corrigeert ongeldige packet_len-tags EN injecteert zelf een
          synthetische tag als er te lang geen geldige detectie binnenkomt,
          zodat repack_bits_bb nooit zonder tag komt te zitten."""

          def __init__(self, tag_name='packet_len', max_len=3000, safe_len=2080):
              gr.sync_block.__init__(
                  self,
                  name='Packet-len tag validator',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.tag_name = tag_name
              self.max_len = int(max_len)
              self.safe_len = int(safe_len)
              self.set_tag_propagation_policy(gr.TPP_DONT)
              self.next_expected_offset = None  # absolute stream-offset

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n = len(in0)
              out[:] = in0

              start_offset = self.nitems_read(0)
              end_offset = start_offset + n

              tags = self.get_tags_in_window(0, 0, n)
              real_tags = []
              for tag in tags:
                  key = pmt.symbol_to_string(tag.key)
                  if key != self.tag_name:
                      continue
                  real_tags.append(tag)

              # Eerste keer: begin gewoon te tellen vanaf nu.
              if self.next_expected_offset is None:
                  self.next_expected_offset = start_offset

              pos = start_offset
              for tag in sorted(real_tags, key=lambda t: t.offset):
                  # Gat vullen: als er tussen 'pos' en deze tag een te grote
                  # afstand zit zonder enige tag, synthetische tags inschuiven.
                  while self.next_expected_offset < tag.offset:
                      self.add_item_tag(
                          0, self.next_expected_offset,
                          pmt.intern(self.tag_name),
                          pmt.from_long(self.safe_len)
                      )
                      self.next_expected_offset += self.safe_len

                  value = pmt.to_long(tag.value)
                  if value <= 0 or value > self.max_len:
                      corrected = self.safe_len
                  else:
                      corrected = value

                  self.add_item_tag(0, tag.offset, tag.key, pmt.from_long(corrected))
                  self.next_expected_offset = tag.offset + corrected

              # Ook binnen dit werkblok vooruitkijken: als er geen enkele tag
              # was, maar we toch de verwachte grens overschrijden, alvast vullen.
              while self.next_expected_offset < end_offset:
                  self.add_item_tag(
                      0, self.next_expected_offset,
                      pmt.intern(self.tag_name),
                      pmt.from_long(self.safe_len)
                  )
                  self.next_expected_offset += self.safe_len

              return n
    max_len: '3000'
    safe_len: '2080'
    tag_name: '"packet_len"'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import subprocess
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Start ffplay als los proces zodra er een bericht binnenkomt
          via de QT GUI Message Button."""

          def __init__(self, udp_port=12345):
              gr.sync_block.__init__(
                  self,
                  name='Start ffplay button handler',
                  in_sig=None,
                  out_sig=None
              )
              self.udp_port = int(udp_port)
              self.process = None
              self.message_port_register_in(pmt.intern('start'))
              self.set_msg_handler(pmt.intern('start'), self.handle_msg)

          def handle_msg(self, msg):
              if self.process is not None and self.process.poll() is None:
                  print("[ffplay] draait al, negeer nieuwe klik.")
                  return

              ffplay_cmd = (
                  f'ffplay -loglevel error -fflags +discardcorrupt+genpts+nobuffer '
                  f'-err_detect ignore_err -max_delay 500000 '
                  f'-f mpegts -i udp://127.0.0.1:{self.udp_port}'
              )

              full_cmd = (
                  f'echo Start ffplay op poort {self.udp_port}... & '
                  f'echo Commando: {ffplay_cmd} & '
                  f'echo. & '
                  f'{ffplay_cmd} & '
                  f'echo. & '
                  f'echo ffplay is gestopt (druk op een toets om dit venster te sluiten) & '
                  f'pause >nul'
              )

              print(f"[ffplay] Start: {ffplay_cmd}")
              self.process = subprocess.Popen(
                  ["cmd", "/c", full_cmd],
                  creationflags=subprocess.CREATE_NEW_CONSOLE
              )

          def stop(self):
              if self.process is not None and self.process.poll() is None:
                  self.process.terminate()
              return True
    udp_port: '12345'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import os
      import tempfile
      import subprocess
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """Start ffmpeg als los proces zodra er een bericht binnenkomt
          via de QT GUI Message Button."""

          def __init__(self, audio_device='CABLE-C Output (VB-Audio Cable C)',
                       udp_port=1234):
              gr.sync_block.__init__(
                  self,
                  name='Start ffmpeg button handler',
                  in_sig=None,
                  out_sig=None
              )
              self.audio_device = str(audio_device)
              self.udp_port = int(udp_port)
              self.process = None
              self.message_port_register_in(pmt.intern('start'))
              self.set_msg_handler(pmt.intern('start'), self.handle_msg)

          def handle_msg(self, msg):
              if self.process is not None and self.process.poll() is None:
                  print("[ffmpeg] draait al, negeer nieuwe klik.")
                  return

              ffmpeg_cmd = (
                  f'ffmpeg -f dshow -i audio="{self.audio_device}" '
                  f'-c:a aac -b:a 128k -ac 2 -ar 48000 -muxrate 200k '
                  f'-f mpegts udp://127.0.0.1:{self.udp_port}'
              )

              # Schrijf het commando naar een tijdelijk .bat-bestand om
              # problemen met haakjes/aanhalingstekens in cmd te vermijden.
              bat_path = os.path.join(tempfile.gettempdir(), "start_ffmpeg_audio.bat")
              with open(bat_path, "w") as f:
                  f.write("@echo off\r\n")
                  f.write("echo Start ffmpeg audio-encoder...\r\n")
                  f.write(f"echo Apparaat: {self.audio_device}\r\n")
                  f.write(f"echo Commando: {ffmpeg_cmd}\r\n")
                  f.write("echo.\r\n")
                  f.write(f"{ffmpeg_cmd}\r\n")
                  f.write("echo.\r\n")
                  f.write("echo ffmpeg is gestopt (druk op een toets om dit venster te sluiten)\r\n")
                  f.write("pause >nul\r\n")

              print(f"[ffmpeg] Start via: {bat_path}")
              self.process = subprocess.Popen(
                  ["cmd", "/c", bat_path],
                  creationflags=subprocess.CREATE_NEW_CONSOLE
              )

          def stop(self):
              if self.process is not None and self.process.poll() is None:
                  self.process.terminate()
              return True
    audio_device: '"CABLE-C Output (VB-Audio Cable C)"'
    udp_port: '1234'
  states: {}
- name: epy_block_timestamp_end
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          """Print een tijdstempel telkens als er een packet_len-tag voorbijkomt."""

          def __init__(self, label='END', tag_name='packet_len'):
              gr.sync_block.__init__(
                  self,
                  name='Packet Timestamp Logger',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.label = label
              self.tag_name = tag_name

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              out[:] = in0
              n = len(in0)
              tags = self.get_tags_in_window(0, 0, n)
              for tag in tags:
                  key = pmt.symbol_to_string(tag.key)
                  if key == self.tag_name:
                      print(f"[{self.label}] {time.time():.3f}  offset={tag.offset}")
              return n
    label: '"END (na Stream CRC32 check)"'
    tag_name: '"packet_len"'
  states: {state: bypassed}
- name: epy_block_timestamp_start
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt
      import time

      class blk(gr.sync_block):
          """Print een tijdstempel telkens als er een packet_len-tag voorbijkomt."""

          def __init__(self, label='START', tag_name='packet_len'):
              gr.sync_block.__init__(
                  self,
                  name='Packet Timestamp Logger',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.label = label
              self.tag_name = tag_name

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              out[:] = in0
              n = len(in0)
              tags = self.get_tags_in_window(0, 0, n)
              for tag in tags:
                  key = pmt.symbol_to_string(tag.key)
                  if key == self.tag_name:
                      print(f"[{self.label}] {time.time():.3f}  offset={tag.offset}")
              return n
    label: '"START (na Correlate Access Code)"'
    tag_name: '"packet_len"'
  states: {state: bypassed}
- name: iio_pluto_sink_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '8'
    bandwidth: '300000'
    buffer_size: '149660'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '439600000'
    samplerate: '1200000'
    type: fc32
    uri: 192.168.1.61
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '300000'
    bbdc: 'True'
    buffer_size: '14966'
    filter_source: '''Auto'''
    frequency: freq_tune
    gain1: '''slow_attack'''
    len_tag_key: ''
    manual_gain1: '73'
    quadrature: 'False'
    rfdc: 'True'
    samplerate: '1200000'
    type: fc32
    uri: 192.168.1.62
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    minoutbuf: buffer_size
    mtu: '10000'
    port: '1234'
    type: UDP_SERVER
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '100'
    port: '12345'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1, 0, 1, 1
    name: '"CONSTELLATION BPSK"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1000000'
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '2048'
    gui_hint: 1, 1, 1, 1
    name: '"RX"'
    type: complex
    ymin: '-160'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: ' 0, 1, 1, 1'
    name: '"Gedecodeerde ontvangst"'
    size: '1024'
    srate: samp_rate*10
    type: float
    ylabel: S2
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0, 0, 1, 1
    label1: S1
    name: '"Raw Ontvangst Packet"'
    size: '1024'
    srate: samp_rate*10
    type: float
    ylabel: S1
    ymax: '0.1'
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: BW_tune
    decim: '1'
    gain: '4'
    minoutbuf: buffer_size
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: BW_tune
    decim: '1'
    gain: '0.6'
    ntaps: '20'
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Start ffplay
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: variable_qtgui_msg_push_button_1
  id: variable_qtgui_msg_push_button
  parameters:
    label: Start ffmpeg (audio-encoder)
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_out
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_out
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_additive_scrambler_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_timestamp_start, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [digital_additive_scrambler_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_additive_scrambler_xx_0_0, '0', digital_crc32_bb_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_constellation_modulator_0, '0', virtual_sink_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', epy_block_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_bb_0, '0', digital_additive_scrambler_xx_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_1, '0', blocks_char_to_float_0_0, '0']
- [digital_crc32_bb_1, '0', epy_block_timestamp_end, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_1, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_timestamp_end, '0', network_udp_sink_0_0, '0']
- [epy_block_timestamp_start, '0', digital_crc32_bb_0, '0']
- [iio_pluto_source_0, '0', root_raised_cosine_filter_0, '0']
- [network_socket_pdu_0, pdus, epy_block_0, pdus]
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [root_raised_cosine_filter_0_0, '0', iio_pluto_sink_0_0_0, '0']
- [variable_qtgui_msg_push_button_0, pressed, epy_block_2, start]
- [variable_qtgui_msg_push_button_1, pressed, epy_block_3, start]
- [virtual_source_0, '0', root_raised_cosine_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
